include libmodbus.inc

SRC_URI[md5sum]="3f94126f7eda99e30d58cdcbf1671dfb"
SRC_URI[sha256sum]="fe0c141cd10d58bb848643f00f2d4b4005214f93312d7b66ac805fd369876651"

S="${WORKDIR}/libmodbus-3.1.6"

