include libmodbus.inc

SRC_URI[md5sum] = "de9f816bad1c2343c00aca536cd4380a"
SRC_URI[sha256sum] = "af8ade1eec30fe3dc6ddf8f711b37f9a931532287f39a40f54e6f475402df389"

S = "${WORKDIR}/libmodbus-3.1.7"
