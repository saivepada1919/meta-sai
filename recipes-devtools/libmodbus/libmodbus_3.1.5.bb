include libmodbus.inc

SRC_URI[md5sum]="47a5591d5622d9b592107e9d2c91f004"
SRC_URI[sha256sum]="9e5c3d8ac83ef59ca8cf4e5c05e82bfcc13606e3d00cf5c2c057178b124dcf6c"

S="${WORKDIR}/libmodbus-3.1.5"

